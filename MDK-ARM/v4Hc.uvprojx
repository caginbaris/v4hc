# Keil uVision project v4Hc.uvprojx, settings and files
target v4Hc (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: v4Hc
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;       ../Drivers/STM32F7xx_HAL_Driver/Inc;       ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;       ../Drivers/CMSIS/Include;       ..\Inc\Comm_Library_Header;       ..\Src\Comm_Library_Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_spi.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_qspi.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rtc.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr_ex.c
  group Application/User
    ../Src/: adc.c main.c gpio.c tim.c dma.c usart.c stm32f7xx_hal_msp.c quadspi.c spi.c rtc.c stm32f7xx_it.c
  group protection
    ./: Faults.c Trips.c current_limiter.c voltage_limiter.c level_check.c
  group control
    ./: PLL.c PI.c references.c Q2Alpha.c Firing.c
  group measurement
    ./: conversion.c RMS.c Qbasic.c Power.c OpenLoopCalc.c
  group modes_states
    ./: states.c startupState.c faultState.c readyState.c runState.c idleState.c stoppedState.c trippedState.c modes.c closedLoopMode.c openLoopMode.c manualVarMode.c manualAngleMode.c firingTestMode.c interMode.c hfMode.c selection.c
  group parameter_config
    ./: parameter_config.c configRoutines.c
  group ios
    ./: ios.c
  group aux_funcitons
    ./: aux_functions.c
  group main_flow
    ./: main_flow.c
  group init_all
    ./: init_all.c
  group Comm Layer
    ../Src/Comm_Library_Source/: CommConfig.c DataParserMerger.c fputc_debug.c Modbus_MasterSlave.c SPI_MasterSlave.c UART_MasterSlave.c
  group Comm Params
    ./: commParams.c
software components: CMSIS:CORE 5.0.0
